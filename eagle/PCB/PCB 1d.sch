File: eagle/PCB/PCB 1d.sch (EAGLE design)
At the start: 29 parts

Commit message: PCB and Case changes
Parts:
- renumbered A1 to DVR_LED, DVR/MODULE-IO to MODULE-IO
